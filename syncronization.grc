options:
  parameters:
    author: Kevin Escobar
    generate_options: qt_gui
    id: syncronization
    output_language: python
    title: Timing Syncronization
  states: {}

blocks:
- name: fc
  id: variable
  parameters:
    value: 2.45e9
  states: {}
- name: loop_bw
  id: variable
  parameters:
    value: 1e3*(2*3.14)/samp_rate
  states: {}
- name: max_freq
  id: variable
  parameters:
    value: 20e3*(2*3.14)/samp_rate
  states: {}
- name: min_freq
  id: variable
  parameters:
    value: 0e3*(2*3.14)/samp_rate
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '3000000'
  states: {}
- name: analog_pll_freqdet_cf_0
  id: analog_pll_freqdet_cf
  parameters:
    max_freq: max_freq
    min_freq: min_freq
    w: loop_bw
  states: {state: disabled}
- name: analog_pll_refout_cc_0
  id: analog_pll_refout_cc
  parameters:
    max_freq: max_freq
    min_freq: min_freq
    w: loop_bw
  states: {state: disabled}
- name: blocks_multiply_conjugate_cc_0
  id: blocks_multiply_conjugate_cc
  parameters: {}
  states: {state: disabled}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: samp_rate/(2*3.14)
    type: float
  states: {state: disabled}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    showports: 'True'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_number_sink_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    type: float
  states: {state: disabled}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    label1: ''
    label2: ''
    size: '1024'
    srate: samp_rate
    type: complex
  states: {state: disabled}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: ''
    center_freq0: fc
    clock_rate: '0.0'
    clock_source0: internal
    dc_offs_enb0: '""'
    dev_args: '""'
    gain0: '30'
    iq_imbal_enb0: '""'
    norm_gain0: 'False'
    samp_rate: samp_rate
    sync: pc_clock
    type: fc32
  states: {}

connections:
- [analog_pll_freqdet_cf_0, '0', blocks_multiply_const_vxx_0, '0']
- [analog_pll_refout_cc_0, '0', blocks_multiply_conjugate_cc_0, '0']
- [blocks_multiply_conjugate_cc_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_multiply_const_vxx_0, '0', qtgui_number_sink_0, '0']
- [uhd_usrp_source_0, '0', analog_pll_freqdet_cf_0, '0']
- [uhd_usrp_source_0, '0', analog_pll_refout_cc_0, '0']
- [uhd_usrp_source_0, '0', blocks_multiply_conjugate_cc_0, '1']
- [uhd_usrp_source_0, '0', qtgui_freq_sink_x_0, '0']

metadata:
  file_format: 1
